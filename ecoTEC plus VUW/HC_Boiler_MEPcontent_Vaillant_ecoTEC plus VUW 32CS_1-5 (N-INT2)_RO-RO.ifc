Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-03-16T16:16:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 16 16:16:59 2022 * Host: MBARNA-RO-LE * Database: C:\Users\mBarna\AppData\Local\Temp\{AC2D9FCB-AAAD-4150-8BE0-C3BA3FF2BCF4}\ifc * Database version: 5507 * Database creation date: Wed Mar 16 16:16:58 2022 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Mar 16 16:16:59 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 16 16:16:59 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, F00
LongName: F00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Constraints(Type) - Elevation Base: Project Base Point

# IfcBoiler: ecoTEC plus VUW 32CS/1-5 (N-INT2), HC_Boiler_MEPcontent_Vaillant_ecoTEC_plus_VUW_CS_RO-RO:ecoTEC plus VUW 32CS/1-5 (N-INT2):1300559
In: F00
Type - Classification: ﻿﻿ ﻿ ﻿﻿ ﻿﻿​ ﻿﻿ ﻿ ​ ﻿﻿ ﻿﻿ ​ ﻿﻿ (Uniformat); Material: Color RGB 121-121-121, Color RGB 244-244-244, Color RGB 040-040-040
Type - Dimensions - Air Supply Connection Diameter: 100 mm; Depth: 348 mm; Domestic Cold Water Diameter: 19.05 mm; Domestic Hot Water Diameter: 19.05 mm; Drain Connection Diameter: 25.4 mm; Flue Gas Connection Diameter: 60 mm; Gas Connection Diameter: 20 mm; Height: 720 mm; Hydronic Connection Diameter: 19.05 mm; Use Nominal Diameter: yes; Width: 440 mm
Type - Electrical - Loads - Voltage: 230 V
Type - Identity Data - Article Description: Centrala murala in condensare; Article Type: ecoTEC plus VUW 32CS/1-5 (N-INT2); Assembly Code: ﻿﻿ ﻿ ﻿﻿ ﻿﻿​ ﻿﻿ ﻿ ​ ﻿﻿ ﻿﻿ ​ ﻿﻿; Base Family Version: 22.02; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Centrala murala in condensare; EMCS Version: 4.0; ETIM Article Class: EC011396; Family Version: 22.02; Keynote: ﻿﻿ ﻿ ﻿﻿ ﻿﻿​ ﻿﻿ ﻿ ​ ﻿﻿ ﻿﻿ ​ ﻿﻿; Manufacturer: Vaillant; Manufacturer Art. No.: 0010024604; Manufacturer URL: https://www.vaillant.com.ro/prima-pagina/; MEPcontent Class: BOILER; Model: ecoTEC plus VUW 32CS/1-5 (N-INT2); OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: ecoTEC plus; Revit Version: 2019; Type Comments: ﻿﻿ ﻿ ﻿﻿ ﻿﻿​ ﻿﻿ ﻿ ​ ﻿﻿ ﻿﻿ ​ ﻿﻿; Type Name: ecoTEC plus VUW 32CS/1-5 (N-INT2); URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Grey: Color RGB 121-121-121; White: Color RGB 244-244-244
Type - Mechanical - Heating Power: 344445
Type - Other - Category: Mechanical Equipment; Family Name: HC_Boiler_MEPcontent_Vaillant_ecoTEC_plus_VUW_CS_RO-RO
Type - Text - Pipe Type Category: M561
Type - Visibility - Drain Visibility: no
Pset_ManufacturerTypeInformation - Manufacturer: Vaillant
Constraints - Offset: 0 mm
Dimensions - Area: 2.78063 m2; Volume: 0.107418 m3
Electrical - Loads - Power: 0 W
Identity Data - Mark: 4
Mechanical - Air Supply Flow: 0 m3/s; Domestic Cold Water Flow: 0 m3/s; Domestic Hot Water Flow: 0 m3/s; Drain Fixture Units: 0; Flue Gas Flow: 0 m3/s; Gas Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; System Classification: Hydronic Supply,Hydronic Return,Undefined,Other,Undefined,Power,Sanitary,Domestic Hot Water,Domestic Cold Water
Other - Family: HC_Boiler_MEPcontent_Vaillant_ecoTEC_plus_VUW_CS_RO-RO: ecoTEC plus VUW 32CS/1-5 (N-INT2); Family and Type: HC_Boiler_MEPcontent_Vaillant_ecoTEC_plus_VUW_CS_RO-RO: ecoTEC plus VUW 32CS/1-5 (N-INT2); Type: HC_Boiler_MEPcontent_Vaillant_ecoTEC_plus_VUW_CS_RO-RO: ecoTEC plus VUW 32CS/1-5 (N-INT2); Type Id: HC_Boiler_MEPcontent_Vaillant_ecoTEC_plus_VUW_CS_RO-RO: ecoTEC plus VUW 32CS/1-5 (N-INT2)
Phasing - Phase Created: 4. Plan over 10 years
Visibility - Show Service Area: no
